FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://s32v234_dtsi.patch \
"