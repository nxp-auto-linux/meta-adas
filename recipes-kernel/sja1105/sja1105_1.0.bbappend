FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://0001-vlan-add-vlan-for-VSDK-specific-configuration.patch \
"
