require recipes-libs/common-libs.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/libs/utils/oal/kernel/build-v234ce-gnu-linux-d"
KO_MODULE_NAME := "oal_cma"
