require recipes-libs/common-libs.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/libs/isp/sequencer/kernel/build-v234ce-gnu-linux-d"
KO_MODULE_NAME := "seq"
