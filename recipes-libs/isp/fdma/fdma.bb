require recipes-libs/common-libs.inc
DEPENDS += "sequencer"
EXTERNALSRC_BUILD := "${EXTERNALSRC}/libs/isp/fdma/kernel/build-v234ce-gnu-linux-d"
