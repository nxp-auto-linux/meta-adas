require recipes-libs/common-libs.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/libs/isp/sram/kernel/build-v234ce-gnu-linux-d"

