require recipes-libs/common-libs.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/libs/isp/h264enc/kernel/build-v234ce-gnu-linux-d"

