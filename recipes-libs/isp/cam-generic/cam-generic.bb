require recipes-libs/common-libs.inc
DEPENDS += "csi"
EXTERNALSRC_BUILD := "${EXTERNALSRC}/libs/isp/cam_generic/kernel/build-v234ce-gnu-linux-d"
KO_MODULE_NAME := "cam"
