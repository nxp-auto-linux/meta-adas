require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/apexcv_pro/apexcv_camdisp_histequal/build-v234ce-gnu-linux-d"
