# don't edit, generated by vsdk_adas.sh script
require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/apexcv_pro/apexcv_orb/build-v234ce-gnu-linux-d"
