require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/apexcv_pro/apexcv_remap/build-v234ce-gnu-linux-d"
