require recipes-demos/common-demos.inc

DEPENDS += "ffmpeg ocv fftw"

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/neon/neon_fftw_cv/build-v234ce-gnu-linux-d"
