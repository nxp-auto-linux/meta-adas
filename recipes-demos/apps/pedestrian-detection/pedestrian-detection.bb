require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/apps/pedestrian_detection/build-v234ce-gnu-linux-d"
