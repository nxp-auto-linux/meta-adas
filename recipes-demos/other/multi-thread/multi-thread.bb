# don't edit, generated by vsdk_adas.sh script
require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/other/multi_thread/build-v234ce-gnu-linux-d"
