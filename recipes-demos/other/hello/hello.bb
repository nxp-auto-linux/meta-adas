require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/other/hello/build-v234ce-gnu-linux-d"
