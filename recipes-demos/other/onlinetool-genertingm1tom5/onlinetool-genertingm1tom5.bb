require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/other/onlinetool_genertingm1tom5/build-v234ce-gnu-linux-d"
