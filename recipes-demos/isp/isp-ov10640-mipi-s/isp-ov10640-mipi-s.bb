require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/isp/isp_ov10640_mipi_s/build-v234ce-gnu-linux-d"
