require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/isp/isp_ov10640_mipi_12bcomb/build-v234ce-gnu-linux-d"
