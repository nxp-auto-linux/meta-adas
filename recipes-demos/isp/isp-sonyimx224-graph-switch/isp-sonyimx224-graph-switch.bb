require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/isp/isp_sonyimx224_graph_switch/build-v234ce-gnu-linux-d"
