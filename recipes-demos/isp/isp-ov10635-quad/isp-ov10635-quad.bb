# don't edit, generated by vsdk_adas.sh script
require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/isp/isp_ov10635_quad/build-v234ce-gnu-linux-d"
