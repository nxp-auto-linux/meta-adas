require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/isp/isp_sonyimx224_generic_encryptedkernel/build-v234ce-gnu-linux-d"
