require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/apex/apex_threads/build-v234ce-gnu-linux-d"
