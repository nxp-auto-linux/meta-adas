require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/apex/apex_integral_image_cv/build-v234ce-gnu-linux-d"

