require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/apex/apex_add/build-v234ce-gnu-linux-d"
