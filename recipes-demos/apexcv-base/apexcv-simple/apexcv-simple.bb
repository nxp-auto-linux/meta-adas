require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/apexcv_base/apexcv_simple/build-v234ce-gnu-linux-d"
