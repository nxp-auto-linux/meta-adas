require recipes-demos/common-demos.inc

EXTERNALSRC_BUILD := "${EXTERNALSRC}/demos/apexcv_base/apexcv_basic/build-v234ce-gnu-linux-d"
