EXTRA_OECONF += '-DDEVRANDOM="\\\"\"/dev/urandom\\\"\"" --with-rand-seed=devrandom'
 
