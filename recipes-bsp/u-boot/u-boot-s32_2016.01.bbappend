FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://0001-secure-monitor-enable-Secure-Monitor-support.patch \
"
