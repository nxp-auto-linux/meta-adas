FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://0001-secure-monitor-enable-Secure-Monitor-support-2018.07.patch \
    file://0002-decrease-h264-decoder-clock-2018.07.patch \
"
